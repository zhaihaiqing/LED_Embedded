# Keil uVision project Project.uvprojx, settings and files
target STM32F4XX (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4_DEMO +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\CMSIS;.\CMSIS\startup\arm;.\Stdlib\inc;.\Stdlib\src;.\User;.\User\bsp;.\Rtt_nano\include;.\Rtt_nano\include\libc;.\Rtt_nano\finsh;.\Rtt_nano\device;.\Rtt_nano
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c scs_thread.c app_key.c app_codec.c app_temp.c app_adc.c app_led.c
  group Bsp
    ./User/bsp/: debug_uart.c delay.c sys.c bsp_gpio.c bsp_temp.c bsp_adc.c bsp_iadc.c bsp_i2c.c bsp_i2c_port.c bsp_oled.c bsp_codec.c bsp_timer.c bsp_eeprom.c
  group StdPeriph_Driver
    ./Stdlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ./User/: system_stm32f4xx.c
  group MDK-ARM
    ./CMSIS/startup/arm/: startup_stm32f40_41xxx.s
  group RTOS_RTT_Nano
    ./Rtt_nano/: board.c rtconfig.h clock.c components.c context_rvds.S cpu.c cpuport.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RTOS_RTT_Nano_Finsh
    ./Rtt_nano/finsh/: cmd.c finsh_port.c msh.c shell.c
